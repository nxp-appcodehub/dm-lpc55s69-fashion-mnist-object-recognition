# Keil uVision project lpcxpresso55s69_object_recognition.uvprojx, settings and files
target lpcxpresso55s69_object_recognition debug (6190000::V6.19::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.17.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: lpcxpresso55s69_object_recognition.out
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core0, MCUXPRESSO_SDK
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;CMSIS;LPC55S69/drivers;component/lists;component/uart;device;drivers;utilities;.\lcd;.\ov7673;.\eiq_lib
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69/arm/LPC55S69_cm33_core0_flash.scf
  link misc: LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --entry=Reset_Handler
LPC55S69/arm/keil_lib_power_cm33_core0.lib
LPC55S69/arm/keil_lib_power_cm33_core0_disable_short_enum_wchar.lib
LPC55S69/arm/keil_lib_power_cm33_core1_disable_short_enum_wchar.lib
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    device/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
    ./drivers/: fsl_i2c.c fsl_i2c.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_spi.c fsl_spi.h fsl_camera_engine_instruction.h LPC55S69_Camera_lib.lib
  group LPC55S69/drivers
    LPC55S69/drivers/: fsl_power.c fsl_power.h
  group source
    source/: hello_world.c
  group startup
    startup/: startup_LPC55S69_cm33_core0.S
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group lcd
    ./lcd/: lcd.c lcd.h
  group ov7673
    ./ov7673/: ov7670.c ov7670.h
  group eiq_lib
    ./eiq_lib/: aia_cmsisnn_cm33.lib eiq_libtf_cm33.lib model_data.s retarget.c
target lpcxpresso55s69_object_recognition release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: lpcxpresso55s69_object_recognition.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core0, MCUXPRESSO_SDK
  c misc: as above
  c include: board;CMSIS;LPC55S69/drivers;component/lists;component/uart;device;drivers;utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69/arm/LPC55S69_cm33_core0_flash.scf
  link misc: as above
